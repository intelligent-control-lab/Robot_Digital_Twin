Commit message: update

File: gazebo/urdf/env.xacro (robot description, xacro)
@@ -59,3 +59,6 @@
   <xacro:testbed_env>
   </xacro:testbed_env>
+  <gazebo reference="env">
+    <material>Galaxea/Sky</material>
+  </gazebo>
 </robot>
